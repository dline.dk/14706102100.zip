Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2017-11-05T22:50:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Nov 05 22:50:36 2017 * Host: DESKTOP-FI6EGIK * Database: C:\Users\CERTIF~1\AppData\Local\Temp\{FF911CF5-B6B3-45C7-9336-D16DF6C12820}\ifc * Database version: 5507 * Database creation date: Sun Nov 05 22:50:36 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Nov 05 22:50:36 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Nov 05 22:50:36 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: dline_Sanitary_ToiletBrushHolder_Satin, 14706102100:dline_Sanitary_ToiletBrushHolder_Satin:194030
In: Level 1
Pset_BuildingElementProxyCommon - Reference: dline_Sanitary_ToiletBrushHolder_Satin
Pset_ManufacturerTypeInformation - ModelReference: 45-35-72/364; Manufacturer: info@dline.com
Constraints - Elevation: 1219.2 mm; Host: <not associated>; Level: Level: Level 1; Default Elevation: 1219.2 mm
Dimensions - Area: 0.0472828 m2; Volume: 0.00146456 m3
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Generic Models; Family: 14706102100: dline_Sanitary_ToiletBrushHolder_Satin; Family and Type: 14706102100: dline_Sanitary_ToiletBrushHolder_Satin; InstallationDate: 1900-12-31T23:59:59; Schedule Level: Level: Level 1; SerialNumber: n/a; TagNumber: n/a; Type: 14706102100: dline_Sanitary_ToiletBrushHolder_Satin; Type Id: 14706102100: dline_Sanitary_ToiletBrushHolder_Satin; WarrantyStartDate: 1900-12-31T23:59:59; AccessibilityPerformance: n/a; AssetType: fixed; CodePerformance: n/a; Color: Steel; Constituents: Toilet brush holder; DurationUnit: year; ExpectedLife: 20 years; Family Name: 14706102100; Features: n/a; Finish: Satin; Grade: n/a; Material: Stainless steel AISI 304; ModelNumber: n/a; ModelReference: 45-35-72/364; Name: ToiletBrushHolder_Satin; ReplacementCost: n/a; Shape: n/a; Size: 400 x 79 x 79 mm; SustainabilityPerformance: n/a; WarrantyDescription: 20 years (non-mechanical/-electronic parts) excluding labor; WarrantyDurationLabor: n/a; WarrantyDurationParts: 20; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: claim@dline.com
Phasing - Phase Created: New Construction
General - Author: Gytautas Balevičius; BIMObjectName: dline_Sanitary_ToiletBrushHolder_Satin; DesignCountry: n/a; ManufacturerName: d line; ManufacturerURL: www.dline.com; MasterFormat2014Code: 10 28 00; MasterFormat2014Description: Toilet, Bath, and Laundry Accessories; NBSCertification: n/a; NBSDescription: Toilet brush holders; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-35-72/364; NBSTypeID: n/a; OmniclassCode: 23-21 43 15 13; OmniclassDescription: Bathroom specialties; ProductFamily: Sanitary; ProductGroup: Bathroom accessories; ProductInformation: http://dline.com/product/knud-holscher-collection-toilet-brush-holder/?attribute_pa_material=satin-stainless-steel-aisi-316&attribute_pa_item=ss-handle-grey-brush#; ProductionCountry: n/a; ProductSKU: 14706102100; Revision: n/a; Uniclass2015Code: Pr_​40_​20_​76_​86; Uniclass2015Title: Toilet brush holders; Uniclass2015Version: Products v1.5; UNSPSCCode: 42211608; Version: 1; Weight Net (kg): 0
Identity Data - Description: Satin AISI 316 stainless steel toilet brush holder; Manufacturer: info@dline.com; Type Name: dline_Sanitary_ToiletBrushHolder_Satin
Materials and Finishes - MainMaterial: AISI 316
